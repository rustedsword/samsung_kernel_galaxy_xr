#include <dt-bindings/battery/sec-battery.h>

&smd {
	sb_tx: sb-tx {
	       aov {
		       high_freq = <144>;
	       };
       };
};

&${mfc_irq_parent} {
	cps_irq_default: cps_irq_default {
		GPIO_CONFIG_PUD_DRV(${cps_irq_gpio}, FUNC_INPUT_WAKEUP, PULL_NONE, DRV_LV1);
	};
};

&${wpc_det_parent} {
	cps_det_default: cps_det_default {
		GPIO_CONFIG_PUD(${cps_det_gpio}, FUNC_INPUT_WAKEUP, PULL_NONE);
	};
};

&${wpc_en_parent} {
	cps_en_default: cps_en_default {
		GPIO_CONFIG_PUD(${cps_en_gpio}, FUNC_OUTPUT_LOW, PULL_NONE);
	};
};

#if ${feature_use_gpio_wpc_pdrc}(get)
&${wpc_pdrc_parent} {
	cps_pdrc_default: cps_pdrc_default {
		GPIO_CONFIG_PUD(${cps_pdrc_gpio}, FUNC_INPUT_WAKEUP, PULL_NONE);
	};
};
#endif

#if ${feature_use_gpio_ping_nen}(get)
&${ping_nen_parent} {
	cps_ping_nen_default: cps_ping_nen_default {
		GPIO_CONFIG_PUD(${cps_ping_nen_gpio}, FUNC_OUTPUT_HIGH, PULL_NONE);
	};
};
#endif

#if ${feature_use_gpio_pdet_b}(get)
&${pdet_b_parent} {
	cps_pdet_b_default: cps_pdet_b_default {
		GPIO_CONFIG_PUD(${cps_pdet_b_gpio}, FUNC_INPUT_WAKEUP, PULL_NONE);
	};
};
#endif

#if ${feature_use_gpio_mag_det}(get)
&${mag_det_parent} {
	cps_mag_det_default: cps_mag_det_default {
		GPIO_CONFIG_PUD(${cps_mag_det_gpio}, FUNC_OUTPUT_HIGH, PULL_NONE);
	};
};
#endif

#if ${feature_use_gpio_wpc_mode}(get)
&${wpc_mode_parent} {
	cps_wpc_mode_default: cps_wpc_mode_default {
		GPIO_CONFIG_PUD(${cps_wpc_mode_gpio}, FUNC_OUTPUT_HIGH, PULL_NONE);
	};
};
#endif

&${wireless_i2c} {
	#address-cells = <1>;
	#size-cells = <0>;
	status = "okay";
	clock-frequency = <100000>;

	cps4038_charger: cps4038-charger@38 {
		compatible = "cps,cps4038-charger";
		reg = <0x38>;
		status = "okay";

		pinctrl-names = "default";
		pinctrl-0 = <&cps_irq_default &cps_det_default &cps_en_default
#if ${feature_use_gpio_wpc_pdrc}(get)
			&cps_pdrc_default
#endif
#if ${feature_use_gpio_ping_nen}(get)
			&cps_ping_nen_default
#endif
#if ${feature_use_gpio_pdet_b}(get)
			&cps_pdet_b_default
#endif
#if ${feature_use_gpio_mag_det}(get)
			&cps_mag_det_default
#endif
#if ${feature_use_gpio_wpc_mode}(get)
			&cps_wpc_mode_default
#endif
			>;

		battery,wpc_int = <SEC_GPIO_REF(${cps_irq_gpio}) 1>; /* MFC_AP_INT */
		battery,wpc_det = <SEC_GPIO_REF(${cps_det_gpio}) 0>; /* WPC_DET */
#if ${feature_use_gpio_mst_pwr_en}(get)
		battery,mst_pwr_en = <SEC_GPIO_REF(${cps_pwr_en_gpio}) 0>; /* MST_PWR_EN */
#endif
#if ${feature_use_gpio_ping_nen}(get)
		battery,wpc_ping_nen = <SEC_GPIO_REF(${cps_ping_nen_gpio}) 1>; /* PING_NEN */
#endif
#if ${feature_use_gpio_pdet_b}(get)
		battery,wpc_pdet_b = <SEC_GPIO_REF(${cps_pdet_b_gpio}) 1>; /* PDET_B */
#endif
		battery,wpc_en = <SEC_GPIO_REF(${cps_en_gpio}) 0>; /* WPC_EN */
#if ${feature_use_gpio_wpc_pdrc}(get)
		battery,wpc_pdrc = <SEC_GPIO_REF(${cps_pdrc_gpio}) 1>; /* VRECT_INT */
#endif
#if ${feature_use_gpio_mag_det}(get)
		battery,wpc_mag_det = <SEC_GPIO_REF(${cps_mag_det_gpio}) 0>; /* MAG_DET */
#endif
#if ${feature_use_gpio_wpc_mode}(get)
		battery,wpc_mode = <SEC_GPIO_REF(${cps_wpc_mode_gpio}) 0>; /* WPC_MODE */
#endif

		battery,charger_name = "${charger_name}";
		battery,fuelgauge_name = "${fuelgauge_name}";
		battery,wireless_charger_name = "cps4038-charger";
		battery,wc_cover_rpp = <0x44>;
		battery,phone_fod_threshold = <0x3b>;
		battery,wireless20_vout_list = <WIRELESS_VOUT_9V /* 0xA0 */
						WIRELESS_VOUT_12V /* 0xA1 */
						WIRELESS_VOUT_12V /* 0xA2 */
						WIRELESS_VOUT_12V /* 0xA3 */
						WIRELESS_VOUT_12V /* 0xA4 */
						WIRELESS_VOUT_12V>; /* 0xA5 */
		battery,wireless20_vrect_list = <MFC_AFC_CONF_12V_TX
						MFC_AFC_CONF_12_5V_TX
						MFC_AFC_CONF_12_5V_TX
						MFC_AFC_CONF_12_5V_TX
						MFC_AFC_CONF_12_5V_TX
						MFC_AFC_CONF_12_5V_TX>;
		battery,wireless20_max_power_list = <SEC_WIRELESS_RX_POWER_12W
						SEC_WIRELESS_RX_POWER_15W
						SEC_WIRELESS_RX_POWER_15W
						SEC_WIRELESS_RX_POWER_15W
						SEC_WIRELESS_RX_POWER_15W
						SEC_WIRELESS_RX_POWER_15W>;

		battery,buds_fod_ta_thresh = <0x0898>; /* 2200mW */
		battery,wpc_vout_ctrl_full = <WIRELESS_VOUT_5V_STEP>;
		battery,mis_align_guide;
		battery,mis_align_target_vout = <5000>;
		battery,mpp_epp_vout = <WIRELESS_VOUT_12V>;

		fod_list {
			count = <1>;

			pad_0x00 { /* DEFAULT PAD */
				bpp { /* DEFAULT OP MODE */
					flag = <(SET_FOD_CC(ADD) | SET_FOD_CV(USE_CC) | SET_FOD_FULL(ADD))>;
					cc = <0x4E 0x0F 0x4E 0x10 0x4E 0x0C 0x4E 0x0C 0x4E 0x0C 0x4E 0x0C 0x4E 0x0D 0x4E 0x0D 0x4E 0x0D 0x4E 0x0D>;
					full = <0xFF 0x7F 0xFF 0x7F 0xFF 0x7F 0xFF 0x7F 0xFF 0x7F
						0xFF 0x7F 0xFF 0x7F 0xFF 0x7F 0xFF 0x7F 0xFF 0x7F>;
				};

				ppde {
					flag = <(SET_FOD_CC(USE_DEF_OP) | SET_FOD_CV(USE_DEF_OP) | SET_FOD_FULL(USE_DEF_OP))>;
				};

				epp {
					flag = <(SET_FOD_CC(USE_DEF_OP) | SET_FOD_CV(USE_DEF_OP) | SET_FOD_FULL(USE_DEF_OP))>;
				};

				mpp {
					flag = <(SET_FOD_CC(USE_DEF_OP) | SET_FOD_CV(USE_DEF_OP) | SET_FOD_FULL(USE_DEF_OP))>;
				};
			};
		};
	};
};
